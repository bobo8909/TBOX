# Keil uVision project SAT.uvprojx, settings and files
target SAT (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SAT +hex
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\HARDWARE\TIMER;..\HARDWARE\CAN;..\APP;..\HARDWARE\Speed;..\HARDWARE\Driver_IO;..\HARDWARE\SPI;..\HARDWARE\AD5734R;..\HARDWARE\IWDG;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\EXTI
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group APP
    ../APP/: CANrecv_task.c CANsend_task.c UartDeal_task.c UartSendData_task.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/CAN/: can.c
    ../HARDWARE/IWDG/: iwdg.c
    ../HARDWARE/Driver_IO/: driver_IO.c
    ../HARDWARE/EXTI/: exti.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_can.c stm32f10x_spi.c stm32f10x_iwdg.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_exti.c
  group README
    ../: README.TXT
